# Keil uVision project stm32f407-ucosii.uvprojx, settings and files
target stm32f407-ucosii (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f407-ucosii +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,GPL_LICENSE_TERMS_ACCEPTED
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\ucosii_kernel\ucos_cfg;..\ucosii_kernel\ucos_cpu;..\ucosii_kernel\ucos_cpu\ARM-Cortex-M4\RealView;..\ucosii_kernel\ucos_debug;..\ucosii_kernel\ucos_debug\RTT;..\ucosii_kernel\ucos_lib;..\ucosii_kernel\ucos_lib\Ports\ARM-Cortex-M4\RealView;..\ucosii_kernel\ucosii\Source;..\ucosii_kernel\ucosii\Ports\ARM-Cortex-M4\Generic\RealView;..\App;..\bsp;..\CycloneTCP\core;..\CycloneTCP\dhcp;..\CycloneTCP\dns;..\CycloneTCP\drivers\phy;..\CycloneTCP\ipv4;..\CycloneTCP\ipv6;..\CycloneTCP\mqtt;..\CycloneTCP\icecast;..\CycloneTCP;..\CycloneCFG;..\CycloneTCP\common;..\CycloneSSL\cyclone_ssl;..\CycloneSSL\cyclone_crypto;..\CycloneSSL\cyclone_crypto\core;..\CycloneSSL\cyclone_crypto\hash;..\CycloneTCP\netbios;..\CycloneSSL\cyclone_crypto\encoding;..\CycloneSSL\cyclone_crypto\aead;..\CycloneSSL\cyclone_crypto\cipher;..\CycloneSSL\cyclone_crypto\cipher_mode;..\CycloneSSL\cyclone_crypto\ecc;..\CycloneSSL\cyclone_crypto\encoding;..\CycloneSSL\cyclone_crypto\hardware;..\CycloneSSL\cyclone_crypto\kdf;..\CycloneSSL\cyclone_crypto\mac;..\CycloneSSL\cyclone_crypto\mpi;..\CycloneSSL\cyclone_crypto\pkc;..\CycloneSSL\cyclone_crypto\pkix;..\CycloneSSL\cyclone_crypto\rng;..\CycloneSSL\cyclone_crypto\xof;..\sfud_spi_flash\sfud\inc;..\easy_flash\inc;../Middlewares/Third_Party/FatFs/src;..\CycloneTCP\http;..\sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application
    ../App/: app_main.c app_imu.c app_mqtt.c app_http.c app_ntp.c app_rtc.c infra_sha256.c
  group Application/User
    ../Src/: main.c gpio.c dma.c eth.c bsp_driver_sd.c sd_diskio.c fatfs.c i2c.c rng.c rtc.c sdio.c spi.c sys.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group ucosii-kernel/cpu
    ../ucosii_kernel/ucos_cpu/: cpu_core.c
    ../ucosii_kernel/ucos_cpu/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group ucosii-kernel/port
    ../ucosii_kernel/ucosii/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group ucosii-kernel/kernel
    ../ucosii_kernel/ucosii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii-kernel/debug
    ../ucosii_kernel/ucos_debug/RTT/: SEGGER_RTT.c
    ../ucosii_kernel/ucos_debug/: os_debug.c
  group ucosii-kernel/lib
    ../ucosii_kernel/ucos_lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../ucosii_kernel/ucos_lib/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group ucosii-kernel/cfg
    ../ucosii_kernel/ucos_cfg/: os_cfg.h lib_cfg.h cpu_cfg.h app_hooks.c app_cfg.h
  group Application/Bsp
    ../bsp/: ring_buffer.c
  group CycloneTCP-Kernel
    ../CycloneTCP/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c dhcp_server.c
    ../CycloneTCP/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../CycloneTCP/ipv4/: arp.c auto_ip.c icmp.c igmp.c ipv4.c ipv4_frag.c ipv4_misc.c
    ../CycloneTCP/ipv6/: icmpv6.c ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c ipv6_routing.c mld.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c slaac.c
    ../CycloneTCP/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c mqtt_client_transport.c
    ../CycloneTCP/core/: bsd_socket.c ethernet.c ethernet_misc.c ip.c net.c net_mem.c nic.c ping.c raw_socket.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../CycloneTCP/web_socket/: web_socket.c web_socket_auth.c web_socket_frame.c web_socket_misc.c web_socket_transport.c
    ../CycloneTCP/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../CycloneTCP/llmnr/: llmnr_client.c llmnr_common.c llmnr_responder.c
    ../CycloneTCP/http/: http_client.c http_client_auth.c http_client_misc.c http_client_transport.c http_common.c
  group CycloneTCP-Config
    ../CycloneCFG/: crypto_config.h net_config.h os_port_config.h tls_config.h
  group CycloneTCP-Common
    ../CycloneTCP/common/: os_port_ucos2.c str.c date_time.c cpu_endian.c debug.c
  group CycloneTCP-SSL
    ../CycloneSSL/cyclone_ssl/: dtls_misc.c dtls_record.c ssl_misc.c tls.c tls_cache.c tls_certificate.c tls_cipher_suites.c tls_client.c tls_client_extensions.c tls_client_fsm.c tls_client_misc.c tls_common.c tls_extensions.c tls_ffdhe.c tls_handshake.c tls_key_material.c tls_misc.c tls_record.c tls_record_decryption.c tls_record_encryption.c tls_server.c tls_server_extensions.c tls_server_fsm.c tls_server_misc.c tls_signature.c tls_ticket.c tls_transcript_hash.c tls13_client.c tls13_client_extensions.c tls13_client_misc.c tls13_common.c tls13_key_material.c tls13_server.c tls13_server_extensions.c tls13_server_misc.c tls13_misc.c
  group CycloneTCP-Crypto
    ../CycloneSSL/cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c tiger.c
    ../CycloneSSL/cyclone_crypto/encoding/: asn1.c base64.c oid.c
    ../CycloneSSL/cyclone_crypto/mac/: hmac.c poly1305.c
    ../CycloneSSL/cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../CycloneSSL/cyclone_crypto/cipher_mode/: cbc.c
    ../CycloneSSL/cyclone_crypto/aead/: ccm.c chacha20_poly1305.c gcm.c
    ../CycloneSSL/cyclone_crypto/pkc/: dh.c dsa.c rsa.c
    ../CycloneSSL/cyclone_crypto/pkix/: pem_import.c pkcs8_key_parse.c x509_cert_parse.c x509_cert_validate.c x509_common.c x509_crl_parse.c x509_crl_validate.c x509_key_parse.c
    ../CycloneSSL/cyclone_crypto/rng/: yarrow.c
    ../CycloneSSL/cyclone_crypto/xof/: keccak.c
    ../CycloneSSL/cyclone_crypto/mpi/: mpi.c
    ../CycloneSSL/cyclone_crypto/kdf/: hkdf.c
    ../CycloneSSL/cyclone_crypto/ecc/: ec.c ecdsa.c ec_curves.c ecdh.c x25519.c curve25519.c
  group CycloneTCP/Driver
    ../CycloneTCP/drivers/mac/: stm32f4xx_eth_driver.c
    ../CycloneTCP/drivers/phy/: lan8720_driver.c
  group sfud_spi_flash/sfud
    ../sfud_spi_flash/sfud/src/: sfud.c sfud_sfdp.c
    ../sfud_spi_flash/sfud/port/: sfud_port.c
  group easyflash/port
    ../easy_flash/port/: ef_port.c
  group easyflash/src
    ../easy_flash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/sensor
    ../sensor/: sd_hal_mpu6050.c
software components: CMSIS:CORE 4.3.0
